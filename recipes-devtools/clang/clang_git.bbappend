#
# Copyright (c) 2026 markyang92
#
# SPDX-License-Identifier: MIT
#

require thin-lto-pgo.inc
